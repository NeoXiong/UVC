# IAR project usbh_sdk_frdmkl26z48m_bm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL26Z128xxx4 Freescale MKL26Z128xxx4
  ICCARM.CCDefines: DEBUG; CPU_MKL26Z128VLL4; IAR; FRDM_KL26Z48M; FREEDOM
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../adapter/sources; ../../../../../adapter/sources/sdk; ../../../../include; ../../../include; ../../../sources/classes/audio; ../../../sources/classes/cdc; ../../../sources/classes/common; ../../../sources/classes/hid; ../../../sources/classes/hub; ../../../sources/classes/msd; ../../../sources/classes/phdc; ../../../sources/classes/video; ../../../sources/controller; ../../../sources/controller/khci; ../../../../hal; ../../../../../../platform/osa/inc; ../../../../../../platform/utilities/inc; ../../../../../../platform/CMSIS/Include; ../../../../../../platform/CMSIS/Include/device; ../../../../../../platform/system/inc; ../../../../../../platform/hal/inc; ../../../../../../rtos; ../../../../../../platform/startup/MKL26Z4; ../../../../../../platform/CMSIS/Include/device/MKL26Z4; ../../../include/frdmkl26z48m
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKL26Z128VLL4; IAR; FRDM_KL26Z48M; FREEDOM
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libgeneric.out
  group adapter
    ../../../../../adapter/sources/: adapter.h adapter_types.h
  group adapter/sdk
    ../../../../../adapter/sources/sdk/: adapter_cfg.h adapter_sdk.c adapter_sdk.h
  group usb_core/host/include
    ../../../include/frdmkl26z48m/: usb_host_config.h
    ../../../include/: usb_host_stack_interface.h
  group usb_core/host/sources/bsp
    ../../../sources/bsp/frdmkl26z48m/: usb_host_bsp.c
  group usb_core/host/sources/class driver/audio
    ../../../sources/classes/audio/: usb_host_audio.c usb_host_audio.h usb_host_audio_intf.c
  group usb_core/host/sources/class driver/cdc
    ../../../sources/classes/cdc/: usb_host_cdc.c usb_host_cdc.h usb_host_cdc_intf.c
  group usb_core/host/sources/class driver/common
    ../../../sources/classes/common/: usb_classes.c
  group usb_core/host/sources/class driver/hid
    ../../../sources/classes/hid/: usb_host_hid.c usb_host_hid.h
  group usb_core/host/sources/class driver/hub
    ../../../sources/classes/hub/: usb_host_hub.c usb_host_hub.h usb_host_hub_prv.h usb_host_hub_sm.c usb_host_hub_sm.h
  group usb_core/host/sources/class driver/msd
    ../../../sources/classes/msd/: usb_host_msd_bo.c usb_host_msd_bo.h usb_host_msd_queue.c usb_host_msd_ufi.c usb_host_msd_ufi.h
  group usb_core/host/sources/class driver/phdc
    ../../../sources/classes/phdc/: usb_host_phdc.c usb_host_phdc.h
  group usb_core/host/sources/class driver/video
    ../../../sources/classes/video/: usb_host_video.c usb_host_video.h usb_host_video_intf.c
  group usb_core/host/sources/controller driver
    ../../../sources/controller/: usb_host.c usb_host.h usb_host_ch9.c usb_host_ch9.h usb_host_common.c usb_host_common.h usb_host_dev_mng.c usb_host_dev_mng.h
  group usb_core/host/sources/controller driver/khci
    ../../../sources/controller/khci/: khci.c khci.h khci_prv.h
  group usb_core/include
    ../../../../include/: compiler.h types.h usb.h usb_desc.h usb_error.h usb_misc.h usb_opt.h usb_types.h
