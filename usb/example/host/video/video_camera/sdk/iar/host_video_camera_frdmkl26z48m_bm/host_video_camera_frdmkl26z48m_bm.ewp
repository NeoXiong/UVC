# IAR project host_video_camera_frdmkl26z48m_bm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL26Z128xxx4 Freescale MKL26Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MKL26Z128VLL4; IAR; FRDM_KL26Z48M; FREEDOM; CLOCK_SETUP=4
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../../../../platform/osa/inc; ../../../../../../../../rtos; ../../../../../../../../platform/utilities/inc; ../../../../../../../../platform/CMSIS/Include; ../../../../../../../../platform/CMSIS/Include/device; ../../../../../../../../platform/startup/MKL26Z4; ../../../../../../../../boards/frdmkl26z48m; ../../../../../../../adapter/sources; ../../../../../../../adapter/sources/sdk; ../../../../../../device/audio/generator; ../../../../../../device/audio/speaker; ../../../../../../device/audio/speaker/sdk; ../../../../../../device/audio/speaker; ../../../../../../device/cdc/virtual_com; ../../../../../../device/composite/hid_audio; ../../../../../../device/composite/msd_cdc; ../../../../../../device/hid/hid_keyboard; ../../../../../../device/hid/hid_mouse; ../../../../../../device/msd; ../../../../../../device/phdc/weighscale; ../../../../../audio/speaker; ../../../../../cdc/cdc_serial; ../../../../../cdc/cdc_serial/sdk/serial_bsp; ../../../../keyboard; ../../../../keyboard+mouse; ../../..; ../../../../../msd/msd_cmd; ../../../../../phdc/11073Manager_Demo; ../../../../../../otg/hid/mouse; ../../../../../../../usb_core/device/include/frdmkl26z48m; ../../../../../../../usb_core/device/include; ../../../../../../../usb_core/device/sources/classes/audio; ../../../../../../../usb_core/device/sources/classes/cdc; ../../../../../../../usb_core/device/sources/classes/common; ../../../../../../../usb_core/device/sources/classes/composite; ../../../../../../../usb_core/device/sources/classes/hid; ../../../../../../../usb_core/device/sources/classes/include; ../../../../../../../usb_core/device/sources/classes/msd; ../../../../../../../usb_core/device/sources/classes/phdc; ../../../../../../../usb_core/device/sources/classes/video; ../../../../../../../usb_core/device/sources/controller/khci; ../../../../../../../usb_core/device/sources/controller; ../../../../../../../usb_core/hal; ../../../../../../../usb_core/host/include/frdmkl26z48m; ../../../../../../../usb_core/host/include; ../../../../../../../usb_core/host/sources/classes/audio; ../../../../../../../usb_core/host/sources/classes/cdc; ../../../../../../../usb_core/host/sources/classes/hid; ../../../../../../../usb_core/host/sources/classes/hub; ../../../../../../../usb_core/host/sources/classes/msd; ../../../../../../../usb_core/host/sources/classes/phdc; ../../../../../../../usb_core/host/sources/classes/printer; ../../../../../../../usb_core/host/sources/classes/video; ../../../../../../../usb_core/host/sources/controller/khci; ../../../../../../../usb_core/host/sources/controller; ../../../../../../../usb_core/include; ../../../../../../../../platform/hal/inc; ../../../../../../../../platform/drivers/inc; ../../../../../../../../platform/drivers/src/gpio; ../../../../../../../../platform/drivers/src/pit; ../../../../../../../../platform/drivers/src/dma; ../../../../../../../../platform/system/inc; ../../../../../../../../boards/common/sgtl5000; ../../../../../../../../platform/drivers/src/uart; ../../../../../../../../platform/drivers/src/sai; ../../../../../../../../platform/drivers/src/edma; ../../../../../../../../platform/drivers/src/i2c
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: host_hid_mouse_bm.out
  ILINK.IlinkConfigDefines: __ram_vector_table__=1; __stack_size__=0x0800; __heap_size__=0x2000
  ILINK.IlinkIcfFile: ../../../../../../../../platform/linker/MKL26Z4/iar/MKL26Z128xxx4_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../usb_core/host/build/iar/usbh_sdk_frdmkl26z48m_bm/debug/libusbh_bm.a; ../../../../../../../../lib/ksdk_platform_lib/iar/KL26Z4/debug/libksdk_platform.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKL26Z128VLL4; IAR; FRDM_KL26Z48M; FREEDOM; CLOCK_SETUP=4
  ICCARM.CCOptLevel: 3
  ILINK.IlinkConfigDefines: __ram_vector_table__=1; __stack_size__=0x0800; __heap_size__=0x1000
  ILINK.IlinkAdditionalLibs: ../../../../../../../usb_core/host/build/iar/usbh_sdk_frdmkl26z48m_bm/release/libusbh_bm.a; ../../../../../../../../lib/ksdk_platform_lib/iar/KL26Z4/release/libksdk_platform.a
  group board
    ../../../../../../../../boards/frdmkl26z48m/: board.h gpio_pins.c gpio_pins.h hardware_init.c pin_mux.c pin_mux.h
  group sources
    ../../../: comm.c comm.h video_camera.c video_camera.h
    ../../../../../../../../platform/drivers/src/dma/: fsl_dma_irq.c
  group startup
    ../../../../../../../../platform/startup/: startup.c startup.h
    ../../../../../../../../platform/startup/MKL26Z4/iar/: startup_MKL26Z4.s
    ../../../../../../../../platform/startup/MKL26Z4/: system_MKL26Z4.c
  group utilities
    ../../../../../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../../../platform/utilities/inc/: fsl_debug_console.h
